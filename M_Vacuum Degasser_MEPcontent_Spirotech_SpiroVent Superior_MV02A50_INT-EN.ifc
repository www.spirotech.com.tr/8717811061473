Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_MV02A50_INT-EN.ifc
Time: 2025-08-05T18:31:52+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_S250_INT-EN:MV02A50, M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_S250_INT-EN:MV02A50:2105832
In: F00
Type - Material: Color RGB 168-168-168, Color RGB 055-055-055, Color RAL 1003
Type - Other - Category: Mechanical Equipment; B: 386 mm; Connection Nominal Diameter: 12.7 mm; Connection Outer Diameter: 21.3 mm; D: 252 mm; Family Name: M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_S250_INT-EN; H: 524 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Diameter: 12.7 mm; Depth: 252 mm; Height: 524 mm; Use Nominal Diameter: yes; Width: 386 mm
Type - Electrical Engineering - Voltage: 0 V
Type - Electrical - Loads - Apparent Load: 0 W
Type - Identity Data - Article Description: Vacuum degasser S250 - 0.5-2.5 bar; Article Type: MV02A50; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Vacuum degasser S250 - 0.5-2.5 bar; EMCS Version: 5.0; ETIM Article Class: EC010260; Family Version: 12.25; GLN: 8717811000007; GTIN: 8717811061473; Manufacturer: Spirotech; Manufacturer Art. No.: MV02A50; Manufacturer URL: https://www.spirotech.com/8717811061473; MEPcontent Class: VACUUM_DEGASSER; Model: MV02A50; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: MV02A50; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 055-055-055; Grey: Color RGB 168-168-168; Yellow: Color RAL 1003
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: MV02A50; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: MV02A50
Other - Bottom Clearance Safe: 250 mm; Family: M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_S250_INT-EN; Family and Type: M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_S250_INT-EN: MV02A50; Left Clearance Safe: 250 mm; Return Actual Offset Safe: 10 mm; Return Negative Offset Safe: 10 mm; Return Position L/R Safe: 0 mm; Return Position Offset Safe: 500 mm; Right Clearance Safe: 250 mm; Supply Actual Offset RL: 10 mm; Supply Negative Offset RL: 10 mm; Supply Position L/R Safe: 0 mm; Supply Position Offset Safe: 500 mm; Top Clearance Safe: 250 mm; Type: MV02A50; Type Id: 2105817
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 6.73936 m2; Return Position L/R: 0 mm; Return Position Offset: 500 mm; Supply Position L/R: 0 mm; Supply Position Offset: 500 mm; Volume: 0.042492 m3
Identity Data - Mark: 4
Mechanical - System Classification: Undefined,Power
Mechanical - Flow - Flow In: 0 m3/s; Flow Out: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 250 mm; Left Clearance: 250 mm; Right Clearance: 250 mm; Service Space: no; Socket Area: no; Top Clearance: 250 mm

# IfcDistributionPort (3)
Description: Flow
Name | FlowDirection | PredefinedType
OutPort_2105832_1 | SOURCE | PIPE
InPort_2105832_2 | SINK | PIPE
Port_2105832_3 | SOURCEANDSINK | CABLE | SystemType: ELECTRICAL
